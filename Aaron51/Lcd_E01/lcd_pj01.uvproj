# Keil uVision project lcd_pj01.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: lcd_pj01.zzz +hex
  c flags: Optimize=8 SizeSpeed=1
  group Application
    ./: lcd_main001.c
  group Utility
    ./: lib_uty001.c
  group LCD Library
    ./: lcd_lib001.c
  group Header Files
    ./: lcd_lib001.h hw_rz51v2.h hw_lcd1602.h lib_uty001.h
