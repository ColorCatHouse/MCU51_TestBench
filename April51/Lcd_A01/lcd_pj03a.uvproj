# Keil uVision project lcd_pj03a.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: lcd_pj03a.zzz +hex
  c flags: Optimize=8 SizeSpeed=1
  group LCD Library
    ./: lcd_lib03.c
  group Utility
    ./: lib_uty.c
  group Application
    ./: lcd003a.c
